# Keil uVision project DesktopWeather.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DesktopWeather +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\src\main;..\src\bsp\inc;..\src\bsp\src;..\src\bsp;..\src\dev;..\src\lcd;..\src\dht11;..\src\esp8266;..\src\cJSON;..\src\malloc;..\src\radio;..\src\LD3320_Driver;..\src\FreeRTOS\include;..\src\FreeRTOS\portable\RVDS\ARM_CM3;..\src\FreeRTOS\portable\MemMang;..\src\FATFS\option;..\src\FATFS;..\src\sd;..\src\FATFS\FATFS_APP;..\src\SYN6288
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group main
    ../src/main/: main.c config.h
  group bsp
    ../src/bsp/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s
    ../src/bsp/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_iwdg.c
  group com
    ../src/main/: system.c
    ../src/dev/: usart1.c SysTick.c
  group dev
    ../src/dev/: rtc.c iic.c timer.c iwdg.c
    ../src/dht11/: dht11.c
  group lcd
    ../src/lcd/: serial_screen.c
  group esp8266
    ../src/esp8266/: esp8266_drive.c http_client.c
  group cJSON
    ../src/cJSON/: utf8togbk.c GbkToUtf_8.c cJSON.c
  group malloc
    ../src/malloc/: malloc.c
  group ld3320
    ../src/LD3320_Driver/: LD3320_main.c LDChip.c Reg_RW.c
  group radio
    ../src/radio/: fm_radio.c tea5767.c
  group syn6288
    ../src/SYN6288/: syn6288.c
